# Keil uVision project CasioDiar.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CasioDiar +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\CasioDiar.sct
  group Source Group 1
    ./Src/: getJoystick.c lcd.c main.c myRTC.c serialPort.c casioDiar.c serialPort_u1.c timerLib.c fifo_buffer.c BMP180_pressure.c mfx_l4.c mfx_l4_i2c.c tm1638.c tm1638_modes.c hi2c0.c
  group Headers
    ./Inc/: getJoystick.h lcd.h myRTC.h serialPort.h casioDiar.h serialPort_u1.h timerLib.h fifo_buffer.h BMP180_pressure.h mfx_l4.h mfx_l4_i2c.h tm1638.h tm1638_modes.h hi2c0.h
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2, Device:Startup 1.3.1
